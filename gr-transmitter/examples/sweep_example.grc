options:
  parameters:
    generate_options: qt_gui
    id: sweep_example
    output_language: python
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: ' 2.465e9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10.5e6
  states: {}
- name: sweep_rate
  id: variable
  parameters:
    value: 18e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 20e6
    freq: samp_rate/sweep_rate
    offset: '-10e6'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate/2.5
    sensitivity: '6.282'
  states: {}
- name: gain
  id: parameter
  parameters:
    value: '80'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 50e6
    fc: '0'
    fftsize: '1024'
    name: '"Sweep"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: cent_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vco_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
