<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_jammer</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cent_freq</value></param>
<param><key>value</key><value> 2.465e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_0</value></param>
<param><key>value</key><value> 2.46012466e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_1</value></param>
<param><key>value</key><value>2.46297466e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_2</value></param>
<param><key>value</key><value>2.46597466e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_3</value></param>
<param><key>value</key><value>2.46902466e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>usrp_freq</value></param>
<param><key>value</key><value>2.46e9</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.46e9</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>2.47e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>amplitude</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>bandwidth</value></param>
<param><key>value</key><value>50e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>jammer_jammer_sg_f</key>
<param><key>id</key><value>jammer_jammer_sg_f_0</value></param>
<param><key>ampl</key><value>ampl</value></param>
<param><key>freq</key><value>1e3</value></param>
<param><key>phase</key><value>phase*0</value></param>
<param><key>sample_freq</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>phase</value></param>
<param><key>value</key><value>3.1416</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>cent_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>usrp_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>jammer_jammer_sg_f_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
